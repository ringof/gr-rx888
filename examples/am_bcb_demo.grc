options:
  parameters:
    author: gr-rx888
    description: Live AM Broadcast Band waterfall via RX888 mk II + librx888 — tunable center frequency, 16x decimation to 2 MS/s complex baseband.
    generate_options: qt_gui
    id: am_bcb_demo
    output_language: python
    title: RX888 AM Broadcast Band
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      ADC rate; firmware-supported
      32e6 or 135e6
    value: '32000000'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: samp_rate / decim = iq_rate
    value: '16'
  states: {}
- name: iq_rate
  id: variable
  parameters:
    comment: complex baseband rate
    value: samp_rate/decim
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      tune across the AM BCB live;
      540 kHz–1700 kHz US allocation
    label: Tune (Hz)
    start: '540000'
    step: '10000'
    stop: '1700000'
    value: '1000000'
  states: {}
- name: rx888_source_0
  id: rx888_source
  parameters:
    atten: '0'
    dither: 'False'
    rand: 'True'
    reference: 27e6
    samprate: samp_rate
    vga_gain: '20'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: |-
      imaginary part of the
      real-to-complex bump
    const: '0'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      lift real ADC stream
      to complex (imag = 0)
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      move center_freq to DC
      of the complex baseband
    freq: '-center_freq'
    sample_rate: samp_rate
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 32 MS/s -> 2 MS/s complex
    decim: decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: iq_rate
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    int_max: '0'
    int_min: '-100'
    name: '"AM BCB waterfall"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.5'
    bw: iq_rate
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    name: '"AM BCB PSD"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}

connections:
- [rx888_source_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
