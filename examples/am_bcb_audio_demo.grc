options:
  parameters:
    author: gr-rx888
    description: Tunable AM Broadcast Band receiver — waterfall + PSD + audio out. Drag the slider, hear the station.
    generate_options: qt_gui
    id: am_bcb_audio_demo
    output_language: python
    title: RX888 AM Broadcast Band (with audio)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: iq_rate
  id: variable
  parameters:
    comment: complex baseband rate
    value: samp_rate/decim
  states: {}
- name: chan_decim
  id: variable
  parameters:
    comment: iq_rate / chan_decim = chan_rate
    value: '10'
  states: {}
- name: chan_rate
  id: variable
  parameters:
    comment: AM channel rate before audio LPF
    value: iq_rate/chan_decim
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: PCM output rate
    value: '48000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: tune across the AM BCB live
    label: Tune (Hz)
    start: '540000'
    step: '10000'
    stop: '1700000'
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.2'
  states: {}
- name: rx888_source_0
  id: rx888_source
  parameters:
    atten: '0'
    dither: 'False'
    rand: 'True'
    reference: 27e6
    samprate: samp_rate
    vga_gain: '20'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-center_freq'
    sample_rate: samp_rate
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 32 MS/s -> 2 MS/s complex
    decim: decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_chan
  id: rational_resampler_xxx
  parameters:
    comment: |-
      2 MS/s -> 200 kHz complex.
      Keeps am_demod_cf's internal Remez LPF design in a sane numerical regime — going straight from 2 MS/s to 50 kHz audio asks for ~1300 taps and pm_remez bails.
    decim: chan_decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '3000'
    audio_stop: '4500'
    chan_rate: chan_rate
    comment: |-
      envelope + DC-remove + LPF (5 kHz)
      200 kHz complex -> 50 kHz real audio
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: 50 kHz -> 48 kHz
    decim: '25'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      ALSA default device.
      Container needs --device /dev/snd
      for the host speakers to hear it.
    samp_rate: audio_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: iq_rate
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    int_max: '0'
    int_min: '-100'
    name: '"AM BCB waterfall"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.5'
    bw: iq_rate
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    name: '"AM BCB PSD"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}

connections:
- [rx888_source_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_chan, '0']
- [rational_resampler_xxx_chan, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
