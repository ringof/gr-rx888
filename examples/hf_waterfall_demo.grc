options:
  parameters:
    author: gr-rx888
    description: |-
      Live HF waterfall from RX888 mk II via librx888.
      Demonstrates gr-rx888 v0.2: real samples from real hardware to a QT GUI sink. Defaults to 32 MS/s (firmware-supported); shows roughly 0-16 MHz of shortwave spectrum.
    generate_options: qt_gui
    id: hf_waterfall_demo
    output_language: python
    title: RX888 HF Waterfall
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000000'
  states: {}
- name: rx888_source_0
  id: rx888_source
  parameters:
    atten: '0'
    dither: 'False'
    rand: 'True'
    reference: 27e6
    samprate: samp_rate
    vga_gain: '10'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: samp_rate/4
    fftsize: '4096'
    int_min: '-100'
    name: '"RX888 HF spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.5'
    bw: samp_rate
    fc: samp_rate/4
    fftsize: '4096'
    name: '"RX888 PSD"'
    type: float
    ymin: '-100'
  states: {}

connections:
- [rx888_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rx888_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
